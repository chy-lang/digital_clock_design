# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ATK-ESP8266;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SD;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\USART2;..\MALLOC;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TEXT;..\USMART;..\STM32F10x_FWLib\inc;..\CORE;..\USER;..\HARDWARE\IIC;..\HARDWARE\myLCD;..\HARDWARE\EXTI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/myLCD/: mylcd.c
    ../HARDWARE/EXTI/: exti.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group ATK_ESP8266
    ../ATK-ESP8266/: apsta.c common.c wifiap.c wifista.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: README.TXT
